Commit message: Edit waffle_stereo model

File: urdf/turtlebot3_waffle_stereo.urdf (robot description, URDF)
Before this commit: robot turtlebot3_waffle, 14 links, 13 joints
Joints:
- joint camera_rgb_optical_stereo_joint: origin xyz=-0.12 0 0 rpy=0 0 0 -> xyz=-0.05 0 0 rpy=0 0 0
